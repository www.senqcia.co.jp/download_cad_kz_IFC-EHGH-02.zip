Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EH500x300-4-42.IFC
Time: 2017-07-21T02:03:11
Author: tkosystem
Organization: Hewlett-Packard Company
Written by: SwIFC
Made in: SolidWorks 2014

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
